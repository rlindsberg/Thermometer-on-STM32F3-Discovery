# IAR project LabbRTOS.ewp, settings and files
configuration LabbRTOS (ARM, debug)
  General.OGChipSelectEditMenu: STM32F303VC ST STM32F303VC
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32F303xC
  ICCARM.CCIncludePath2: ../Inc; C:/Users/Ag/STM32Cube/Repository/STM32Cube_FW_F3_V1.9.0/Drivers/STM32F3xx_HAL_Driver/Inc; C:/Users/Ag/STM32Cube/Repository/STM32Cube_FW_F3_V1.9.0/Drivers/STM32F3xx_HAL_Driver/Inc/Legacy; C:/Users/Ag/STM32Cube/Repository/STM32Cube_FW_F3_V1.9.0/Middlewares/Third_Party/FreeRTOS/Source/portable/IAR/ARM_CM4F; C:/Users/Ag/STM32Cube/Repository/STM32Cube_FW_F3_V1.9.0/Drivers/CMSIS/Device/ST/STM32F3xx/Include; C:/Users/Ag/STM32Cube/Repository/STM32Cube_FW_F3_V1.9.0/Middlewares/Third_Party/FreeRTOS/Source/include; C:/Users/Ag/STM32Cube/Repository/STM32Cube_FW_F3_V1.9.0/Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS; C:/Users/Ag/STM32Cube/Repository/STM32Cube_FW_F3_V1.9.0/Drivers/CMSIS/Include
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ..\Inc
  OBJCOPY.OOCOutputFile: Project.srec
  ILINK.IlinkOutputFile: LabbRTOS.out
  ILINK.IlinkIcfFile: stm32f303xc_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ./: startup_stm32f303xc.s
  group Application/User
    ../Src/: freertos.c gpio.c main.c stm32f3xx_hal_msp.c stm32f3xx_hal_timebase_TIM.c stm32f3xx_it.c
  group Drivers/CMSIS
    ../Src/: system_stm32f3xx.c
  group Drivers/STM32F3xx_HAL_Driver
    C:/Users/Ag/STM32Cube/Repository/STM32Cube_FW_F3_V1.9.0/Drivers/STM32F3xx_HAL_Driver/Src/: stm32f3xx_hal.c stm32f3xx_hal_cortex.c stm32f3xx_hal_dma.c stm32f3xx_hal_flash.c stm32f3xx_hal_flash_ex.c stm32f3xx_hal_gpio.c stm32f3xx_hal_i2c.c stm32f3xx_hal_i2c_ex.c stm32f3xx_hal_pwr.c stm32f3xx_hal_pwr_ex.c stm32f3xx_hal_rcc.c stm32f3xx_hal_rcc_ex.c stm32f3xx_hal_tim.c stm32f3xx_hal_tim_ex.c
  group Middlewares/FreeRTOS
    C:/Users/Ag/STM32Cube/Repository/STM32Cube_FW_F3_V1.9.0/Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
    C:/Users/Ag/STM32Cube/Repository/STM32Cube_FW_F3_V1.9.0/Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
    C:/Users/Ag/STM32Cube/Repository/STM32Cube_FW_F3_V1.9.0/Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    C:/Users/Ag/STM32Cube/Repository/STM32Cube_FW_F3_V1.9.0/Middlewares/Third_Party/FreeRTOS/Source/portable/IAR/ARM_CM4F/: port.c portasm.s
